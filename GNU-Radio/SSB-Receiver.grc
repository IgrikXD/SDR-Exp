<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ssb_receiver</value></param>
<param><key>author</key><value>Ihar Yatsevich</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>SSB Receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>50300000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>51500</value></param>
<param><key>label</key><value>Frequency offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>60000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resamp_factor</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>256000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ssb_width</value></param>
<param><key>value</key><value>3000</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>station_freq</value></param>
<param><key>value</key><value>center_freq+freq_offset+ssb_width/2</value></param>
<param><key>label</key><value>Station frequency</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>0.3</value></param>
<param><key>decay_rate</key><value>0.00001</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>max_gain</key><value>1</value></param>
<param><key>reference</key><value>0.2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate/resamp_factor</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate/resamp_factor</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>D:\ssb_lsb_256k_complex2.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.15</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>resamp_factor</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,ssb_width/2,100)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Signal spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>50</value></param>
<param><key>ymin</key><value>-50</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/resamp_factor</value></param>
<param><key>fc</key><value>center_freq+freq_offset</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>FIR Filter</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plotfreq</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>3</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
